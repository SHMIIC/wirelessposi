# Keil uVision project wirelessposi.uvproj, settings and files
target wirelessposi (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: wirelessposi +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib;.\src
  group src
    ./src/: config.h main.c rey_config.h rey_config.c
  group lib
    ./lib/: timer.c USART.C spi.c
